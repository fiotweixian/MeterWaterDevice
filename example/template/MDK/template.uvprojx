# Keil uVision project template.uvprojx, settings and files
target FiotDecWater_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HC32L176PATA HDSC
  pack: HDSC.HC32L17X.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;..\..\..\system;..\..\..\math;..\..\..\midware\H32_FLASH;..\..\..\midware\HC32_BATTERY;..\..\..\midware\HC32_BEEP;..\..\..\midware\HC32_CRC;..\..\..\midware\HC32_DEBUG;..\..\..\midware\HC32_EEPROM;..\..\..\midware\HC32_KEY;..\..\..\midware\HC32_LCD;..\..\..\midware\HC32_LED;..\..\..\midware\HC32_LMODE;..\..\..\midware\HC32_LPTIMER;..\..\..\midware\HC32_NBIOT;..\..\..\midware\HC32_PCNT;..\..\..\midware\HC32_RTC;..\..\..\midware\HC32_SE;..\..\..\midware\HC32_VALVE;..\..\..\midware\HC32_WDT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l17x.s
    ../../../mcu/common/: system_hc32l17x.c interrupts_hc32l17x.c
  group source
    ../source/: main.c
  group driver
    ../../../driver/src/: ddl.c sysctrl.c adc.c adt.c aes.c bgr.c bt.c crc.c dac.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group middle
    ../../../midware/HC32_BATTERY/: hc32_battery.c
    ../../../midware/HC32_BEEP/: hc32_beep.c
    ../../../midware/HC32_CRC/: hc32_crc.c
    ../../../midware/HC32_DEBUG/: hc32_debug.c
    ../../../midware/HC32_EEPROM/: hc32_eeprom.c
    ../../../midware/HC32_KEY/: hc32_key.c
    ../../../midware/HC32_LCD/: hc32_lcd.c
    ../../../midware/HC32_LMODE/: hc32_lmode.c
    ../../../midware/HC32_LPTIMER/: hc32_lptimer.c
    ../../../midware/HC32_NBIOT/: hc32_bc35.c
    ../../../midware/HC32_PCNT/: hc32_pcnt.c
    ../../../midware/HC32_RTC/: hc32_rtc.c
    ../../../midware/HC32_SE/: hc32_se.c
    ../../../midware/HC32_VALVE/: hc32_valve.c
    ../../../midware/HC32_WDT/: hc32_wdt.c
    ../../../midware/H32_FLASH/: hc32_flash.c
  group system
    ../../../system/: system.c
  group math
    ../../../math/: common.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
